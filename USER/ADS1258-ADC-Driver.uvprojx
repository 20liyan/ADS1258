# Keil uVision project ADS1258-ADC-Driver.uvprojx, settings and files
target ADS1258 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADS1258 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\ADS1258;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADS1258/: ads1258.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c zk.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
